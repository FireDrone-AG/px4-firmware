## src/drivers/adc/ads7828/Kconfig
```kconfig
menuconfig DRIVERS_ADC_ADS7828
	bool "ADS7828 driver"
	default n
	---help---
		Enable support for ADS7828
```
